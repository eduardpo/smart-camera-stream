PTEST_ENABLED = "0"
PACKAGECONFIG:remove = "tests"
