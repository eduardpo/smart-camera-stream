# This file is part of the meta-picam layer for Yocto SDK.
PACKAGECONFIG:append = " dnn"